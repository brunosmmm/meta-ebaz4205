
RDEPENDS:${PN} += "${PYTHON_PN}-stack-data \
                  "